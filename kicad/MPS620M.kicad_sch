File: kicad/MPS620M.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Redone A1.
Other:
- sheet A3 20V supply renamed A3 ±20V supply
- company: KEPCO -> A design by KEPCO
